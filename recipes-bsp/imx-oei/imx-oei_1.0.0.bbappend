SRC_URI = "${IMX_OEI_SRC};branch=${SRCBRANCH}"
IMX_OEI_SRC = "git://github.com/QNAP-android-internal/imx-oei.git;protocol=https"
SRCBRANCH = "iei-imx_6.12.34_2.1.0"
SRCREV = "4ff2b5fef2672214df9c4ffad76f89ca08210718"

OEI_BOARD = "smarc-imx95"
