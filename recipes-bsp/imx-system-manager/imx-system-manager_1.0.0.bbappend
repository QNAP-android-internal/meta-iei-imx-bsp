SRC_URI = "${IMX_SYSTEM_MANAGER_SRC};branch=${SRCBRANCH}"
IMX_SYSTEM_MANAGER_SRC = "git://github.com/QNAP-android-internal/imx-sm.git;protocol=https"
SRCBRANCH = "iei-imx_6.12.34_2.1.0"
SRCREV = "e052568758eb0845a9162bc98247a4bc21927c35"
