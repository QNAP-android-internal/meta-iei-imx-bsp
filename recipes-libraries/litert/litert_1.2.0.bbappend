FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://0001-Fix-XNNPACK-KleidiAI-SHA256-hash.patch"
