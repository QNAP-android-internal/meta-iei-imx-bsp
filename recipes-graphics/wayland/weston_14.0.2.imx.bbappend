FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += " file://0001-frontend-support-WESTON_DRM_PRIMARY-env-for-output-order.patch"
